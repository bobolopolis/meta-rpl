# Use the stronger sha256 for verification
PACKAGECONFIG:append = " sha256"

# Use curl over wget
PACKAGECONFIG:append = " curl"
